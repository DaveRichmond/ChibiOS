# Keil uVision project ch.uvprojx, settings and files
target Demo (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ch
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: __heap_base__=Image$$$$RW_IRAM1$$$$ZI$$$$Limit __heap_end__=Image$$$$RW_IRAM2$$$$Base
  c include: ..\;..\..\..\..\os\common\ports\ARMCMx\devices\KL2x;..\..\..\..\os\ext\CMSIS\include;..\..\..\..\os\ext\CMSIS\KINETIS;..\..\..\..\os\rt\ports\ARMCMx;..\..\..\..\os\rt\ports\ARMCMx\compilers\RVCT;..\..\..\..\os\rt\include;..\..\..\..\os\hal\osal\rt;..\..\..\..\os\hal\include;..\..\..\..\os\hal\boards\FREESCALE_FREEDOM_KL25Z;..\..\..\..\os\hal\ports\common\ARMCMx;..\..\..\..\os\hal\ports\KINETIS\KL2x;..\..\..\..\os\hal\ports\KINETIS\LLD;..\..\..\..\test;..\..\..\..\test\rt;..\..\..\..\os\various;..\..\..\..\os\various\devices_lib\accel
  asm misc: --cpreproc
  asm include: ..\;..\..\..\..\os\common\ports\ARMCMx\devices\KL2x;..\..\..\..\os\rt\ports\ARMCMx
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  memory RVCT10: RAM 0x20003000 size 0x1
  group startup
    ../../../../os/common/ports/ARMCMx/devices/KL2x/: cmparams.h
    ../../../../os/common/ports/ARMCMx/compilers/RVCT/: cstartup.s vectors.s
  group cmsis
    ../../../../os/ext/CMSIS/include/: core_cmInstr.h core_cm0.h core_cmFunc.h
    ../../../../os/ext/CMSIS/KINETIS/: kl25z.h
  group kernel port
    ../../../../os/rt/ports/ARMCMx/: chcore.c chcore_v6m.c
    ../../../../os/rt/ports/ARMCMx/compilers/RVCT/: chcoreasm_v6m.s chtypes.h
  group kernel
    ../../../../os/rt/src/: chcond.c chdebug.c chdynamic.c chevents.c chheap.c chmboxes.c chmemcore.c chmempools.c chmsg.c chmtx.c chqueues.c chregistry.c chschd.c chsem.c chstats.c chsys.c chthreads.c chtm.c chvt.c
  group osal
    ../../../../os/hal/osal/rt/: osal.c
  group hal port
    ../../../../os/hal/ports/common/ARMCMx/: nvic.c
    ../../../../os/hal/ports/KINETIS/KL2x/: hal_lld.c pal_lld.c pwm_lld.c serial_lld.c st_lld.c
    ../../../../os/hal/ports/KINETIS/LLD/: adc_lld.c ext_lld.c i2c_lld.c
  group hal
    ../../../../os/hal/src/: adc.c can.c dac.c ext.c gpt.c hal.c hal_mmcsd.c hal_queues.c i2c.c i2s.c icu.c mac.c mmc_spi.c pal.c pwm.c rtc.c sdc.c serial.c serial_usb.c spi.c st.c uart.c usb.c
  group board
    ../../../../os/hal/boards/FREESCALE_FREEDOM_KL25Z/: board.c board.h
  group test
    ../../../../test/rt/: test.c testbmk.c testdyn.c testevt.c testheap.c testmbox.c testmsg.c testmtx.c testpools.c testqueues.c testsem.c testthd.c
  group demo
    ../: main.c mcuconf.h chconf.h halconf.h
