# Keil uVision project ch.uvprojx, settings and files
target Demo (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ch
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: __heap_base__=Image$$$$RW_IRAM1$$$$ZI$$$$Limit __heap_end__=Image$$$$RW_IRAM2$$$$Base
  c misc: --c99
  c include: ..\;..\..\..\..\os\common\ports\ARMCMx\devices\STM32F0xx;..\..\..\..\os\ext\CMSIS\include;..\..\..\..\os\ext\CMSIS\ST;..\..\..\..\os\rt\ports\ARMCMx;..\..\..\..\os\rt\ports\ARMCMx\compilers\RVCT;..\..\..\..\os\rt\include;..\..\..\..\os\hal\osal\rt;..\..\..\..\os\hal\include;..\..\..\..\os\hal\boards\ST_STM32F0_DISCOVERY;..\..\..\..\os\hal\ports\common\ARMCMx;..\..\..\..\os\hal\ports\STM32\STM32F0xx;..\..\..\..\os\hal\ports\STM32\LLD;..\..\..\..\os\hal\ports\STM32\LLD\GPIOv2;..\..\..\..\os\hal\ports\STM32\LLD\I2Cv2;..\..\..\..\os\hal\ports\STM32\LLD\RTCv2;..\..\..\..\os\hal\ports\STM32\LLD\SPIv2;..\..\..\..\os\hal\ports\STM32\LLD\TIMv1;..\..\..\..\os\hal\ports\STM32\LLD\USARTv2;..\..\..\..\os\hal\ports\STM32\LLD\USBv1;..\..\..\..\test;..\..\..\..\test\rt
  asm misc: --cpreproc
  asm include: ..\;..\..\..\..\os\common\ports\ARMCMx\devices\STM32F0xx;..\..\..\..\os\rt\ports\ARMCMx
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x20002000 size 0x1
  group startup
    ../../../../os/common/ports/ARMCMx/compilers/RVCT/: cstartup.s vectors.s
    ../../../../os/common/ports/ARMCMx/devices/STM32F0xx/: cmparams.h
  group cmsis
    ../../../../os/ext/CMSIS/include/: core_cmInstr.h core_cm0.h core_cmFunc.h
    ../../../../os/ext/CMSIS/ST/: stm32f0xx.h
  group kernel port
    ../../../../os/rt/ports/ARMCMx/: chcore.c chcore.h chcore_v6m.c chcore_v6m.h chcore_timer.h
    ../../../../os/rt/ports/ARMCMx/compilers/RVCT/: chtypes.h chcoreasm_v6m.s
  group kernel
    ../../../../os/rt/src/: chcond.c chdebug.c chdynamic.c chevents.c chheap.c chmboxes.c chmemcore.c chmempools.c chmsg.c chmtx.c chqueues.c chregistry.c chschd.c chsem.c chstats.c chsys.c chthreads.c chtm.c chvt.c
    ../../../../os/rt/include/: ch.h chbsem.h chcond.h chdebug.h chdynamic.h chevents.h chheap.h chlicense.h chmboxes.h chmemcore.h chmempools.h chmsg.h chmtx.h chqueues.h chregistry.h chschd.h chsem.h chstats.h chstreams.h chsys.h chsystypes.h chthreads.h chtm.h chvt.h
  group osal
    ../../../../os/hal/osal/rt/: osal.c osal.h
  group hal port
    ../../../../os/hal/ports/common/ARMCMx/: nvic.c
    ../../../../os/hal/ports/STM32/STM32F0xx/: stm32_dma.c hal_lld.c adc_lld.c ext_lld_isr.c
    ../../../../os/hal/ports/STM32/LLD/: ext_lld.c
    ../../../../os/hal/ports/STM32/LLD/GPIOv2/: pal_lld.c
    ../../../../os/hal/ports/STM32/LLD/I2Cv2/: i2c_lld.c
    ../../../../os/hal/ports/STM32/LLD/RTCv1/: rtc_lld.c
    ../../../../os/hal/ports/STM32/LLD/SPIv2/: spi_lld.c
    ../../../../os/hal/ports/STM32/LLD/TIMv1/: gpt_lld.c icu_lld.c pwm_lld.c st_lld.c
    ../../../../os/hal/ports/STM32/LLD/USARTv2/: serial_lld.c uart_lld.c
    ../../../../os/hal/ports/STM32/LLD/USBv1/: usb_lld.c
  group hal
    ../../../../os/hal/src/: adc.c ext.c gpt.c hal.c hal_mmcsd.c hal_queues.c i2c.c i2s.c icu.c mac.c mmc_spi.c pal.c pwm.c rtc.c sdc.c serial.c serial_usb.c spi.c st.c uart.c usb.c can.c dac.c
  group board
    ../../../../os/hal/boards/ST_STM32F0_DISCOVERY/: board.c board.h
  group test
    ../../../../test/rt/: test.c testbmk.c testdyn.c testevt.c testheap.c testmbox.c testmsg.c testmtx.c testpools.c testqueues.c testsem.c testthd.c
  group demo
    ../: main.c mcuconf.h chconf.h halconf.h
