# Keil uVision project nil.uvprojx, settings and files
target Demo (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) IRAM2(0x10000000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: nil
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: CORTEX_USE_FPU=1 __heap_base__=Image$$$$RW_IRAM1$$$$ZI$$$$Limit __heap_end__=Image$$$$RW_IRAM2$$$$Base
  c misc: -USTM32F303xC
  c include: ..\;..\..\..\..\os\common\ports\ARMCMx\devices\STM32F3xx;..\..\..\..\os\ext\CMSIS\include;..\..\..\..\os\ext\CMSIS\ST;..\..\..\..\os\nil\ports\ARMCMx;..\..\..\..\os\nil\ports\ARMCMx\compilers\RVCT;..\..\..\..\os\nil\include;..\..\..\..\os\hal\osal\nil;..\..\..\..\os\hal\lib\streams;..\..\..\..\os\hal\include;..\..\..\..\os\hal\boards\ST_STM32F3_DISCOVERY;..\..\..\..\os\hal\ports\common\ARMCMx;..\..\..\..\os\hal\ports\STM32\STM32F3xx;..\..\..\..\os\hal\ports\STM32\LLD;..\..\..\..\os\hal\ports\STM32\LLD\GPIOv2;..\..\..\..\os\hal\ports\STM32\LLD\I2Cv2;..\..\..\..\os\hal\ports\STM32\LLD\RTCv2;..\..\..\..\os\hal\ports\STM32\LLD\SPIv2;..\..\..\..\os\hal\ports\STM32\LLD\TIMv1;..\..\..\..\os\hal\ports\STM32\LLD\USARTv2;..\..\..\..\os\hal\ports\STM32\LLD\USBv1;..\..\..\..\test;..\..\..\..\test\nil;..\..\..\..\test\lib;..\..\..\..\os\various
  asm define: CORTEX_USE_FPU=1
  asm misc: --cpreproc
  asm include: ..\;..\..\..\..\os\common\ports\ARMCMx\devices\STM32F3xx;..\..\..\..\os\nil\ports\ARMCMx
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT6: RAM 0x10000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x2000c000 size 0x1
  group startup
    ../../../../os/common/ports/ARMCMx/devices/STM32F3xx/: cmparams.h
    ../../../../os/common/ports/ARMCMx/compilers/RVCT/: cstartup.s vectors.s
  group cmsis
    ../../../../os/ext/CMSIS/include/: core_cmInstr.h core_cm4.h core_cm4_simd.h core_cmFunc.h
    ../../../../os/ext/CMSIS/ST/: stm32f3xx.h
  group kernel port
    ../../../../os/nil/ports/ARMCMx/: nilcore.c nilcore_v7m.c
    ../../../../os/nil/ports/ARMCMx/compilers/RVCT/: nilcoreasm_v7m.s niltypes.h
  group kernel
    ../../../../os/nil/src/: nil.c
  group osal
    ../../../../os/hal/osal/nil/: osal.c
  group hal port
    ../../../../os/hal/ports/common/ARMCMx/: nvic.c
    ../../../../os/hal/ports/STM32/STM32F3xx/: stm32_dma.c hal_lld.c adc_lld.c ext_lld_isr.c
    ../../../../os/hal/ports/STM32/LLD/GPIOv2/: pal_lld.c
    ../../../../os/hal/ports/STM32/LLD/I2Cv2/: i2c_lld.c
    ../../../../os/hal/ports/STM32/LLD/RTCv2/: rtc_lld.c
    ../../../../os/hal/ports/STM32/LLD/SPIv2/: spi_lld.c
    ../../../../os/hal/ports/STM32/LLD/TIMv1/: gpt_lld.c icu_lld.c pwm_lld.c st_lld.c
    ../../../../os/hal/ports/STM32/LLD/USARTv2/: serial_lld.c uart_lld.c
    ../../../../os/hal/ports/STM32/LLD/USBv1/: usb_lld.c
  group hal
    ../../../../os/hal/src/: adc.c can.c dac.c ext.c gpt.c hal.c hal_mmcsd.c hal_queues.c i2c.c i2s.c icu.c mac.c mmc_spi.c pal.c pwm.c rtc.c sdc.c serial.c serial_usb.c spi.c st.c uart.c usb.c
  group board
    ../../../../os/hal/boards/ST_STM32F3_DISCOVERY/: board.c
  group test
    ../../../../test/nil/: test_root.c test_sequence_001.c test_sequence_002.c
    ../../../../test/lib/: ch_test.c
  group demo
    ../: main.c halconf.h mcuconf.h nilconf.h
