# Keil uVision project ch.uvprojx, settings and files
target Demo (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ch
  c flags: Optim=4 oTime=1 uC99=1 wLevel=2
  c define: CORTEX_USE_FPU=1 __heap_base__=Image$$$$RW_IRAM1$$$$ZI$$$$Limit __heap_end__=Image$$$$RW_IRAM2$$$$Base
  c misc: -USTM32F407xx
  c include: ..\;..\..\..\..\os\common\ports\ARMCMx\devices\STM32F4xx;..\..\..\..\os\ext\CMSIS\include;..\..\..\..\os\ext\CMSIS\ST;..\..\..\..\os\rt\ports\ARMCMx;..\..\..\..\os\rt\ports\ARMCMx\compilers\RVCT;..\..\..\..\os\rt\include;..\..\..\..\os\hal\osal\rt;..\..\..\..\os\hal\lib\streams;..\..\..\..\os\hal\include;..\..\..\..\os\hal\boards\ST_STM32F4_DISCOVERY;..\..\..\..\os\hal\ports\common\ARMCMx;..\..\..\..\os\hal\ports\STM32\STM32F4xx;..\..\..\..\os\hal\ports\STM32\LLD;..\..\..\..\os\hal\ports\STM32\LLD\DACv1;..\..\..\..\os\hal\ports\STM32\LLD\GPIOv2;..\..\..\..\os\hal\ports\STM32\LLD\I2Cv1;..\..\..\..\os\hal\ports\STM32\LLD\OTGv1;..\..\..\..\os\hal\ports\STM32\LLD\RTCv2;..\..\..\..\os\hal\ports\STM32\LLD\SPIv1;..\..\..\..\os\hal\ports\STM32\LLD\TIMv1;..\..\..\..\os\hal\ports\STM32\LLD\USARTv1;..\..\..\..\os\hal\ports\STM32\LLD\FSMCv1;..\..\..\..\test;..\..\..\..\test\rt;..\..\..\..\os\various;..\..\..\..\os\various\devices_lib\accel
  asm define: CORTEX_USE_FPU=1 _ARMCC_VERSION=1
  asm misc: --cpreproc
  asm include: ..\;..\..\..\..\os\common\ports\ARMCMx\devices\STM32F4xx;..\..\..\..\os\rt\ports\ARMCMx
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x10000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x1
  group startup
    ../../../../os/common/ports/ARMCMx/devices/STM32F4xx/: cmparams.h
    ../../../../os/common/ports/ARMCMx/compilers/RVCT/: cstartup.s vectors.s
  group cmsis
    ../../../../os/ext/CMSIS/include/: core_cmInstr.h core_cm4.h core_cm4_simd.h core_cmFunc.h
    ../../../../os/ext/CMSIS/ST/: stm32f4xx.h
  group kernel port
    ../../../../os/rt/ports/ARMCMx/: chcore.c chcore_v7m.c
    ../../../../os/rt/ports/ARMCMx/compilers/RVCT/: chcoreasm_v7m.s chtypes.h
  group kernel
    ../../../../os/rt/src/: chcond.c chdebug.c chdynamic.c chevents.c chheap.c chmboxes.c chmemcore.c chmempools.c chmsg.c chmtx.c chqueues.c chregistry.c chschd.c chsem.c chstats.c chsys.c chthreads.c chtm.c chvt.c
  group osal
    ../../../../os/hal/osal/rt/: osal.c osal.h
  group hal port
    ../../../../os/hal/ports/common/ARMCMx/: nvic.c
    ../../../../os/hal/ports/STM32/STM32F4xx/: stm32_dma.c hal_lld.c adc_lld.c ext_lld_isr.c
    ../../../../os/hal/ports/STM32/LLD/: can_lld.c ext_lld.c mac_lld.c sdc_lld.c
    ../../../../os/hal/ports/STM32/LLD/DACv1/: dac_lld.c
    ../../../../os/hal/ports/STM32/LLD/GPIOv2/: pal_lld.c
    ../../../../os/hal/ports/STM32/LLD/I2Cv1/: i2c_lld.c
    ../../../../os/hal/ports/STM32/LLD/OTGv1/: usb_lld.c
    ../../../../os/hal/ports/STM32/LLD/RTCv2/: rtc_lld.c
    ../../../../os/hal/ports/STM32/LLD/SPIv1/: spi_lld.c i2s_lld.c
    ../../../../os/hal/ports/STM32/LLD/TIMv1/: gpt_lld.c icu_lld.c pwm_lld.c st_lld.c
    ../../../../os/hal/ports/STM32/LLD/USARTv1/: serial_lld.c uart_lld.c
  group hal
    ../../../../os/hal/src/: adc.c can.c dac.c ext.c gpt.c hal.c hal_mmcsd.c hal_queues.c i2c.c i2s.c icu.c mac.c mmc_spi.c pal.c pwm.c rtc.c sdc.c serial.c serial_usb.c spi.c st.c uart.c usb.c
  group board
    ../../../../os/hal/boards/ST_STM32F4_DISCOVERY/: board.c board.h
  group test
    ../../../../test/rt/: test.c testbmk.c testdyn.c testevt.c testheap.c testmbox.c testmsg.c testmtx.c testpools.c testqueues.c testsem.c testthd.c
  group demo
    ../: main.c mcuconf.h chconf.h halconf.h usbcfg.c usbcfg.h
  group hal\libs\streams
    ../../../../os/hal/lib/streams/: chprintf.c memstreams.c nullstreams.c
  group devices\accel
    ../../../../os/various/devices_lib/accel/: lis302dl.c
  group various
    ../../../../os/various/: shell.c
