# Keil uVision project ch.uvprojx, settings and files
target Demo (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) IRAM2(0x10000000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ch
  c flags: Optim=4 oTime=1 uC99=1 wLevel=2
  c define: CORTEX_USE_FPU=1 __heap_base__=Image$$$$RW_IRAM1$$$$ZI$$$$Limit __heap_end__=Image$$$$RW_IRAM2$$$$Base
  c misc: -USTM32F303xC
  c include: ..\;..\..\..\..\os\common\ports\ARMCMx\devices\STM32F3xx;..\..\..\..\os\ext\CMSIS\include;..\..\..\..\os\ext\CMSIS\ST;..\..\..\..\os\rt\ports\ARMCMx;..\..\..\..\os\rt\ports\ARMCMx\compilers\RVCT;..\..\..\..\os\rt\include;..\..\..\..\os\hal\osal\rt;..\..\..\..\os\hal\include;..\..\..\..\os\hal\boards\ST_STM32F3_DISCOVERY;..\..\..\..\os\hal\ports\common\ARMCMx;..\..\..\..\os\hal\ports\STM32\STM32F3xx;..\..\..\..\os\hal\ports\STM32\LLD;..\..\..\..\os\hal\ports\STM32\LLD\GPIOv2;..\..\..\..\os\hal\ports\STM32\LLD\I2Cv2;..\..\..\..\os\hal\ports\STM32\LLD\RTCv2;..\..\..\..\os\hal\ports\STM32\LLD\SPIv2;..\..\..\..\os\hal\ports\STM32\LLD\TIMv1;..\..\..\..\os\hal\ports\STM32\LLD\USARTv2;..\..\..\..\os\hal\ports\STM32\LLD\USBv1;..\..\..\..\test;..\..\..\..\test\rt;..\..\..\..\os\hal\lib\streams;..\..\..\..\os\various
  asm define: CORTEX_USE_FPU=1
  asm misc: --cpreproc
  asm include: ..\;..\..\..\..\os\common\ports\ARMCMx\devices\STM32F3xx;..\..\..\..\os\rt\ports\ARMCMx
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x2000c000 size 0x1
  group startup
    ../../../../os/common/ports/ARMCMx/devices/STM32F3xx/: cmparams.h
    ../../../../os/common/ports/ARMCMx/compilers/RVCT/: cstartup.s vectors.s
  group cmsis
    ../../../../os/ext/CMSIS/include/: core_cmInstr.h core_cm4.h core_cm4_simd.h core_cmFunc.h
    ../../../../os/ext/CMSIS/ST/: system_stm32f3xx.h
  group kernel port
    ../../../../os/rt/ports/ARMCMx/: chcore_v7m.h chcore.c chcore.h chcore_timer.h chcore_v7m.c
    ../../../../os/rt/ports/ARMCMx/compilers/RVCT/: chtypes.h chcoreasm_v7m.s
  group kernel
    ../../../../os/rt/include/: ch.h chbsem.h chcond.h chdebug.h chdynamic.h chevents.h chheap.h chmboxes.h chmemcore.h chmempools.h chmsg.h chmtx.h chqueues.h chregistry.h chschd.h chsem.h chstats.h chstreams.h chsys.h chthreads.h chtm.h chvt.h
    ../../../../os/rt/src/: chcond.c chdebug.c chdynamic.c chevents.c chheap.c chmboxes.c chmemcore.c chmempools.c chmsg.c chmtx.c chqueues.c chregistry.c chschd.c chsem.c chstats.c chsys.c chthreads.c chtm.c chvt.c
  group osal
    ../../../../os/hal/osal/rt/: osal.c osal.h
  group hal port
    ../../../../os/hal/ports/STM32/STM32F3xx/: adc_lld.c adc_lld.h ext_lld_isr.c ext_lld_isr.h hal_lld.c hal_lld.h stm32_dma.c stm32_dma.h stm32_isr.h stm32_rcc.h stm32_registry.h
    ../../../../os/hal/ports/STM32/LLD/: can_lld.c can_lld.h ext_lld.c ext_lld.h
    ../../../../os/hal/ports/STM32/LLD/GPIOv2/: pal_lld.c pal_lld.h
    ../../../../os/hal/ports/STM32/LLD/I2Cv2/: i2c_lld.c i2c_lld.h
    ../../../../os/hal/ports/STM32/LLD/RTCv2/: rtc_lld.c rtc_lld.h
    ../../../../os/hal/ports/STM32/LLD/SPIv2/: spi_lld.c spi_lld.h
    ../../../../os/hal/ports/STM32/LLD/TIMv1/: gpt_lld.c gpt_lld.h icu_lld.c icu_lld.h pwm_lld.c pwm_lld.h st_lld.c st_lld.h stm32_tim.h
    ../../../../os/hal/ports/STM32/LLD/USARTv2/: serial_lld.c serial_lld.h uart_lld.c uart_lld.h
    ../../../../os/hal/ports/STM32/LLD/USBv1/: stm32_usb.h usb_lld.c usb_lld.h
    ../../../../os/hal/ports/common/ARMCMx/: nvic.c nvic.h
  group hal
    ../../../../os/hal/include/: adc.h can.h ext.h gpt.h hal.h hal_channels.h hal_ioblock.h hal_mmcsd.h hal_queues.h hal_streams.h i2c.h icu.h mmc_spi.h pal.h pwm.h sdc.h serial.h serial_usb.h spi.h st.h uart.h usb.h
    ../../../../os/hal/src/: adc.c can.c ext.c gpt.c hal.c hal_mmcsd.c hal_queues.c i2c.c icu.c mmc_spi.c pal.c pwm.c sdc.c serial.c serial_usb.c spi.c st.c uart.c usb.c
  group board
    ../../../../os/hal/boards/ST_STM32F3_DISCOVERY/: board.c board.h
  group test
    ../../../../test/rt/: test.c test.h testbmk.c testbmk.h testdyn.c testdyn.h testevt.c testevt.h testheap.c testheap.h testmbox.c testmbox.h testmsg.c testmsg.h testmtx.c testmtx.h testpools.c testpools.h testqueues.c testqueues.h testsem.c testsem.h testthd.c testthd.h
  group demo
    ../: main.c mcuconf.h chconf.h halconf.h usbcfg.c usbcfg.h
  group streams
    ../../../../os/hal/lib/streams/: chprintf.c memstreams.c nullstreams.c
  group various
    ../../../../os/various/: shell.c
